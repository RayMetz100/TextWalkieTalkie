# Keil uVision project LEDsAndSwitches.uvprojx, settings and files
target dpp-dbg (ARM-ADS)
  device: STM32L053R8 STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.3.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: dpp-qv
  AfterMake: fromelf --bin --output .\dbg\dpp-qv.bin .\dbg\dpp-qv.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: C:\qp\qpc\include;C:\qp\qpc\ports\arm-cm\qv\arm
  asm define: Stack_Size=1024 Heap_Size=0
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --entry Reset_Handler
  group Source Code
    ../: bsp.c
    ../../: bsp.h dpp.h main.c philo.c table.c system_stm32l0xx.c core_cmInstr.h stm32l0xx.h
target dpp-rel (ARM-ADS)
  device: STM32L053R8 STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.3.0
  cpu: as above
  output: dpp-qv
  AfterMake: fromelf --bin --output .\rel\dpp-qv.bin .\rel\dpp-qv.axf
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG
  c include: ..\..;..\..\..\..\..\include;..\..\..\..\..\source;..\..\..\..\..\ports\arm-cm\qv\arm;..\..\..\..\..\3rd_party\CMSIS\Include;..\..\..\..\..\3rd_party\nucleo-l053r8
  asm define: Stack_Size=1024 Heap_Size=0
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --entry Reset_Handler
target dpp-spy (ARM-ADS)
  device: STM32L053R8 STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.3.0
  cpu: as above
  output: dpp-qv
  AfterMake: fromelf --bin --output .\spy\dpp-qv.bin .\spy\dpp-qv.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: Q_SPY
  c include: as above
  asm define: Stack_Size=1024 Heap_Size=0
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --entry Reset_Handler
