# Keil uVision project KielMdkProject.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32L053R8 STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.3.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: KielMdkProject
  AfterMake: fromelf --bin --output .\Objects\KielMdkProject.bin .\Objects\KielMdkProject.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\STMicroelectronics\STM32L0xx\Include;..\STMicroelectronics\STM32L0xx\Source\Templates\arm;..\STMicroelectronics\STM32L0xx\Source\Templates;..\CMSIS\Include;..\myBoardSupport;..\myProgram;..\qp\qpc\include;..\qp\qpc\source;..\qp\qpc\ports\arm-cm\qv\arm
  asm define: Stack_Size=1024 Heap_Size=0
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --entry Reset_Handler
  group myProgram
    ../myProgram/: main.c blinky.c LEDFunctions.c
  group myBoardSupport
    ../myBoardSupport/: bsp.c bsp.h
  group STMicroelectronics
    ../STMicroelectronics/STM32L0xx/Include/: stm32l0xx.h stm32l053xx.h system_stm32l0xx.h
    ../STMicroelectronics/STM32L0xx/Source/Templates/: system_stm32l0xx.c
    ../STMicroelectronics/STM32L0xx/Source/Templates/arm/: startup_stm32l053xx.s
  group CMSIS
    ../CMSIS/Include/: core_cm0plus.h
  group QP
    ../qp/qpc/source/: qep_hsm.c qep_msm.c qf_act.c qf_actq.c qf_defer.c qf_dyn.c qf_mem.c qf_pkg.h qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c qv.c
  group QP_port
    ../qp/qpc/ports/arm-cm/qv/arm/: qep_port.h qf_port.h qs_port.h qv_port.h
